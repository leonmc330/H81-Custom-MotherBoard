# Repository leonmc330/H81-Custom-MotherBoard

File README.md:

# H81-Custom-MotherBoard — Boardview → KiCad PCB Toolchain

Reverse-engineering toolchain for the **Gigabyte GA-H81M-S1** motherboard.
Reads a `.tvw` boardview file, exports component/pin data as CSV, and regenerates
a full KiCad 6 project (PCB layout + schematic + footprint library).

---

## Directory Structure

```
H81-Custom-MotherBoard/
  boardview/              Python boardview viewer (Thermetery Technology)
  boards/GA-H81M-S1/     TVW board files
  pipeline/
    input/                components.csv + pins.csv (exported from viewer)
    scripts/              Python export scripts
      lib.py              Shared utilities
      export_pcb.py       CSV → output.kicad_pcb
      export_sch.py       CSV → output.kicad_sch
      export_footprints.py CSV → footprints.pretty/*.kicad_mod
    kicad/                KiCad project files (output.kicad_pro, .kicad_pcb, .kicad_sch)
    footprints.pretty/    Generated KiCad footprint library
    router/               Specctra DSN file for autorouter
  docs/                   GA-H81M-S1-schematic.pdf
  launch_viewer.bat       Opens boardview viewer
  export_pcb.bat          Runs export_pcb.py
  export_sch.bat          Runs export_sch.py
  export_footprints.bat   Runs export_footprints.py
```

---

## Pipeline

```
boards/GA-H81M-S1/GA-H81M-S1 r3.0.tvw
        │
        ▼  boardview viewer (launch_viewer.bat)
           Export mode: Components → pipeline/input/components.csv
           Export mode: Pins      → pipeline/input/pins.csv
        │
        ├─▶  export_pcb.bat          → pipeline/kicad/output.kicad_pcb
        ├─▶  export_sch.bat          → pipeline/kicad/output.kicad_sch
        └─▶  export_footprints.bat   → pipeline/footprints.pretty/
```

---

## Quick Start

1. **View board:** double-click `launch_viewer.bat`
2. **Export CSVs:** in the viewer, use Cycle/Export mode to export components and pins into `pipeline/input/`
3. **Generate PCB:** double-click `export_pcb.bat`
4. **Generate schematic:** double-click `export_sch.bat`
5. **Generate footprints:** double-click `export_footprints.bat`
6. **Open in KiCad:** open `pipeline/kicad/output.kicad_pro`

---

## Coordinate System

- TVW file units: 1 unit ≈ 0.000325 mm (3077 units/mm)
- `PIN_SCALE = 2.54 × 0.0001` in export_pcb.py converts TVW units to mm
- `FLIP_X = FLIP_Y = True` — both flips cancel out, preserving orientation
- Pin world positions in `pins.csv` have rotation baked in at export time

## Notes

- `export_pcb.py` is stable — do not edit its logic
- Device names in `components.csv` may contain commas; `lib.read_components()` parses from the right
- KiCad footprint library `reforming` is declared in `pipeline/kicad/fp-lib-table`

## KiCad design src/H81-Custom-MotherBoard.kicad_pcb

Schematic: H81-Custom-MotherBoard.kicad_sch

Parts (part):
A1: 33/8P4R/4; 33_8P4R_4
ATX1: APW/2*12/BK/VA/SN/2SHK/PA66; APW_2_12_BK_VA_SN_2SHK_PA66
ATX_12V1: APW/2*2/BK/P/4.2/SN/PA66; APW_2_2_BK_P_4.2_SN_PA66
AUDIO1: A3RP/13P/BL,LI,PK/RA/D/1/B; A3RP_13P_BL_LI_PK_RA_D_1_B
BAT1: BAT-SK/BK/P/S/D/SN; BAT-SK_BK_P_S_D_SN
BC5, BC6, BC8, BC63, BC146, BC161: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
BC20, BC21, BC147, BC150, BC152, BC153, BC158: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
BC67, BC75: 0.01u/4/X7R/25V/K; 0.01u_4_X7R_25V_K
BC78: 0.01u/4/X7R/25V/K/X; 0.01u_4_X7R_25V_K_X
BC79, BC84, BC140, BC148, BC151: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
BC149: 4.7u/6/X5R/6.3V/K; 4.7u_6_X5R_6.3V_K
BC154: 10u/6/X5R/6.3V/M; 10u_6_X5R_6.3V_M
BC162: 10u/6/X5R/6.3V/M/X; 10u_6_X5R_6.3V_M_X
BC164: 1n/4/X7R/50V/K; 1n_4_X7R_50V_K
BC179: 22u/8/X5R/6.3V/M; 22u_8_X5R_6.3V_M
B_BIOS1: MASK/32M/SPI/SO8/200mil/S/X; MASK_32M_SPI_SO8_200mil_S_X
C9, C16: 0.01u/4/X7R/25V/K; 0.01u_4_X7R_25V_K
C12, C33, C40, C143: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
C31, C32: 100p/4/NPO/50V/J/X; 100p_4_NPO_50V_J_X
C34, C35, C36: 10p/4/NPO/50V/J/X; 10p_4_NPO_50V_J_X
C37, C38, C39: 22p/4/NPO/50V/J/X; 22p_4_NPO_50V_J_X
C76, C80, C104: 1n/4/X7R/50V/K; 1n_4_X7R_50V_K
C100: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
C119: 2.2n/4/X7R/50V/K; 2.2n_4_X7R_50V_K
C120: 1u/6/X7R/16V/K/X; 1u_6_X7R_16V_K_X
C121, C136, C318, C323: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
C131, C322: 1u/6/X7R/16V/K; 1u_6_X7R_16V_K
C132: 1u/4/X5R/6.3V/K/X; 1u_4_X5R_6.3V_K_X
C133, C193: 3.3n/4/X7R/50V/K; 3.3n_4_X7R_50V_K
C134: 22p/4/NPO/50V/J; 22p_4_NPO_50V_J
C144: 1n/4/X7R/50V/K/X; 1n_4_X7R_50V_K_X
CBC1, CBC2, CBC5, CBC6, CBC7, CBC8, CBC9, CBC10, CBC11, CBC12, CBC34, CBC35: 10u/6/X5R/6.3V/M; 10u_6_X5R_6.3V_M
CBC3, CBC4, CBC19, CBC20, CBC23, CBC24, CBC29, CBC30, CBC36, CBC37: 180p/4/NPO/50V/J/X; 180p_4_NPO_50V_J_X
CBC26: 1n/4/X7R/50V/K; 1n_4_X7R_50V_K
CBC32: 22p/4/NPO/50V/J/X; 22p_4_NPO_50V_J_X
CBC38: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
CBC42, CBC43: 100p/4/NPO/50V/J/X; 100p_4_NPO_50V_J_X
CD1: AZ2225-01L/SOD323/X; AZ2225-01L_SOD323_X
CEC1, CEC2, CEC6: 100uF/D/10V/6*5; 100uF_D_10V_6_5
CLR_CMOS1: PH/1*2/BK/2.54/VA/D; PH_1_2_BK_2.54_VA_D
COUPON1, COUPON2: COUPON/X; COUPON_X
CQ2, CQ4: BAT54A/SOT23/200mA; BAT54A_SOT23_200mA
CR1, CR5, CR8, CR11, CR13, CR14, CR17, CR22, CR53, CR57: 62/4; 62_4
CR6, CR7, CR54, CR58: 22K/4; 22K_4
CR12, CR65: 0/4/X; 0_4_X
CR16, CR19: 8.2K/4; 8.2K_4
CR18, CR34, CR55: 20K/4/1; 20K_4_1
CR20: 5.1K/4/1; 5.1K_4_1
CR21: 2.2/6; 2.2_6
CR23: 10K/4/1; 10K_4_1
CR24, CR49, CR60, CR79, CR80: 0/4/SHT/M/X; 0_4_SHT_M_X
CR44: 47/4/1; 47_4_1
CR50: 0/6/X; 0_6_X
CR51, CR63: 0/6/SHT/M/X; 0_6_SHT_M_X
CR59: 39.2K/4/1; 39.2K_4_1
CR61: 22/4; 22_4
CR78: 8.2K/4/X; 8.2K_4_X
CRN1: 8.2K/8P4R/4; 8.2K_8P4R_4
CU1: ALC887-VD2-CG/LQFP48/9V/S; ALC887-VD2-CG_LQFP48_9V_S
D3: CD4148WP/1206/300mA; CD4148WP_1206_300mA
D4: BAT54A/SOT23/200mA; BAT54A_SOT23_200mA
D5: SDM20E40C/0.4A/SOT23; SDM20E40C_0.4A_SOT23
DAC1: 1u/6/X7R/16V/K; 1u_6_X7R_16V_K
DAC2: 0.22u/6/X7R/16V/K; 0.22u_6_X7R_16V_K
DAC3: 1n/4/X7R/50V/K; 1n_4_X7R_50V_K
DAL1: 0.68uH/40A/IMD119/M/D; 0.68uH_40A_IMD119_M_D
DAR1, DAR6: 2.2/6; 2.2_6
DAR2: 8.2K/4; 8.2K_4
DAR3, DAR8: 0/6/SHT/M/X; 0_6_SHT_M_X
DAR4, DAR5: 0/4/SHT/M/X; 0_4_SHT_M_X
DAR7: 3.6K/4/1; 3.6K_4_1
DAR9, DAR11, DAR12: 10K/4/1; 10K_4_1
DAR10: 10/4; 10_4
DBC1, DBC11: 1u/6/X7R/16V/K; 1u_6_X7R_16V_K
DBC2, DBC21, DBC22, DBC23: 0.22u/6/X7R/16V/K; 0.22u_6_X7R_16V_K
DBC3: 1n/4/X7R/50V/K; 1n_4_X7R_50V_K
DBC10, DBC12: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
DBC13, DBC28, DBC48: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
DBC14: 470p/4/X7R/50V/K; 470p_4_X7R_50V_K
DBC15: 47p/4/NPO/50V/J; 47p_4_NPO_50V_J
DBC16, DBC24: 330p/4/NPO/50V/J; 330p_4_NPO_50V_J
DBC17: 180p/4/NPO/50V/J; 180p_4_NPO_50V_J
DBC18: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
DBC19, DBC20: 0.01u/4/X7R/25V/K/X; 0.01u_4_X7R_25V_K_X
DBC25, DBC26: 0.22u/4/X5R/6.3V/K; 0.22u_4_X5R_6.3V_K
DBC27: 0.47u/4/X5R/6.3V/K; 0.47u_4_X5R_6.3V_K
DBC46: 1u/6/X7R/16V/K/X; 1u_6_X7R_16V_K_X
DBL1: 0.68uH/40A/IMD119/M/D; 0.68uH_40A_IMD119_M_D
DBR1, DBR6: 2.2/6; 2.2_6
DBR2: 8.2K/4; 8.2K_4
DBR3, DBR8: 0/6/SHT/M/X; 0_6_SHT_M_X
DBR4, DBR5: 0/4/SHT/M/X; 0_4_SHT_M_X
DBR7: 3.6K/4/1; 3.6K_4_1
DBR9, DBR11, DBR12: 10K/4/1; 10K_4_1
DBR10: 10/4; 10_4
DC17: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
DCC1, DCC4: 1u/6/X7R/16V/K; 1u_6_X7R_16V_K
DCC2: 0.22u/6/X7R/16V/K; 0.22u_6_X7R_16V_K
DCC3: 1n/4/X7R/50V/K; 1n_4_X7R_50V_K
DCC5: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
DCL1: 0.68uH/40A/IMD119/M/D; 0.68uH_40A_IMD119_M_D
DCQ2: MASK/NTMFS4C08NT1G/PPAK/1113pF/5.8m/X; MASK_NTMFS4C08NT1G_PPAK_1113pF_5.8m_X
DCR1, DCR6: 2.2/6; 2.2_6
DCR2: 8.2K/4; 8.2K_4
DCR3, DCR8: 0/6/SHT/M/X; 0_6_SHT_M_X
DCR4, DCR5: 0/4/SHT/M/X; 0_4_SHT_M_X
DCR7: 3.6K/4/1; 3.6K_4_1
DCR9, DCR11, DCR12: 10K/4/1; 10K_4_1
DCR10: 10/4; 10_4
DCR13, DCR14: 1/6; 1_6
DCU1: ISL6208BCRZ/DFN8; ISL6208BCRZ_DFN8
DDR3_1, DDR3_2: DDR3/240/BK/VA/D; DDR3_240_BK_VA_D
DEC2, DEC4, DEC6, DEC7: 560u/FP/D/6.3V/69/A/11m; 560u_FP_D_6.3V_69_A_11m
DEC3, DEC5: MASK/560u/FP/D/6.3V/69/A/11m/X; MASK_560u_FP_D_6.3V_69_A_11m_X
DEC10, DEC12: 270u/FP/D/16V/8C/A/10m; 270u_FP_D_16V_8C_A_10m
DEC11: MASK/270u/FP/D/16V/8C/A/10m/X; MASK_270u_FP_D_16V_8C_A_10m_X
DR37: 2K/4/1; 2K_4_1
DR41, DR42, DR43: 2.2/6; 2.2_6
DR44: 100/4/1/X; 100_4_1_X
DR45, DR68: 100/4/1; 100_4_1
DR46: 51/4/1; 51_4_1
DR47: 499/4/1; 499_4_1
DR50: 169K/4/1/X; 169K_4_1_X
DR51: 40.2K/4/1; 40.2K_4_1
DR52: 3.3K/4/1; 3.3K_4_1
DR53, DR100: 1K/4/1; 1K_4_1
DR54: 3K/4/1; 3K_4_1
DR55, DR58: 10/4; 10_4
DR56: 0/4/SHT/M/X; 0_4_SHT_M_X
DR57: 8.06K/4/1; 8.06K_4_1
DR59: 0/4/X; 0_4_X
DR60: 2.61K/4/1; 2.61K_4_1
DR61: 41.2K/4/1; 41.2K_4_1
DR62: 34K/4/1; 34K_4_1
DR63: 64.9K/4/1; 64.9K_4_1
DR64: 3.24K/4/1; 3.24K_4_1
DR66: 11K/4/1; 11K_4_1
DR67: 604/4/1; 604_4_1
DR69: 27.4K/4/1; 27.4K_4_1
DR92: 10K/4/1; 10K_4_1
DRT1: 10K/1/4/S; 10K_1_4_S
DU1: ISL95812HRZ-T/QFN32; ISL95812HRZ-T_QFN32
EC6, EC9, EC13, EC15: 1000u/D/6.3V/8C/30m; 1000u_D_6.3V_8C_30m
EC11: MASK/560u/FP/D/6.3V/69/A/11m/X; MASK_560u_FP_D_6.3V_69_A_11m_X
EC12: 560u/FP/D/6.3V/69/A/11m; 560u_FP_D_6.3V_69_A_11m
EC14: 100u/D/10V/57; 100u_D_10V_57
EC16: 270u/FP/D/16V/8C/A/10m; 270u_FP_D_16V_8C_A_10m
EOS1: AZ2225-01L/SOD323; AZ2225-01L_SOD323
ESD1, ESD3, ESD4, ESD5, ESD6, ESD18: AZC099-04S/SOT23-6L; AZC099-04S_SOT23-6L
F11: SPR-P260T/6V/8/S; SPR-P260T_6V_8_S
FB1, FB2, FB3: 60/4/3A/S; 60_4_3A_S
FC1: 1u/6/X7R/16V/K/X; 1u_6_X7R_16V_K_X
FC3: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
FC4: 10u/8/X5R/16V/K; 10u_8_X5R_16V_K
FF1: SPR-P200T/6V/8/S; SPR-P200T_6V_8_S
FPESD1: AZC099-04S/SOT23-6L; AZC099-04S_SOT23-6L
FR1: SPR-P200T/6V/8/S; SPR-P200T_6V_8_S
FR2: 1K/4/1; 1K_4_1
FR3: 22K/4; 22K_4
FR4: 8.2K/4/X; 8.2K_4_X
FU14: NCT3941S-A/SOP8-EP; NCT3941S-A_SOP8-EP
F_PANEL1: PH/2*10K10,12,13/WH/2.54/VA/D; PH_2_10K10_12_13_WH_2.54_VA_D
F_USB1, F_USB2: PH/2*5K9/WH/2.54/VA/D; PH_2_5K9_WH_2.54_VA_D
G1: NTMFS4C10NT1G/PPAK/970pF/7.3m; NTMFS4C10NT1G_PPAK_970pF_7.3m
G2: 32M/SPI/SO8/200mil/S; 32M_SPI_SO8_200mil_S
G2#2: PCI-E/1X-36P/BK/OL; PCI-E_1X-36P_BK_OL
G2#3: PH/2*5K8/BK/2.54/VA/D; PH_2_5K8_BK_2.54_VA_D
G#2, G#3, G#4: NTMFS4C10NT1G/PPAK/970pF/7.3m; NTMFS4C10NT1G_PPAK_970pF_7.3m
G#5: 25M/20p/30ppm/49US/20/D; 25M_20p_30ppm_49US_20_D
G#6, G#7: MASK/NTMFS4C08NT1G/PPAK/1113pF/5.8m/X; MASK_NTMFS4C08NT1G_PPAK_1113pF_5.8m_X
G#8, G#9, G#10, G#11, G#12, G#13: NTMFS4C08NT1G/PPAK/1113pF/5.8m; NTMFS4C08NT1G_PPAK_1113pF_5.8m
G#14: 100uF/D/10V/6*5; 100uF_D_10V_6_5
K1, K2, K3, K4, K5, K6: K1_ICT/X; K1_ICT_X
KB_MS1: KB/MS/6P/PC99/OS/RA/D/2; KB_MS_6P_PC99_OS_RA_D_2
L3, L4: 1uH/36A/IMD109/M/D; 1uH_36A_IMD109_M_D
LABC2: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
LABC3, LABC5, LABC6, LABC8, LABC9, LABC14, LABC18: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
LABC4: 100p/4/NPO/50V/J/X; 100p_4_NPO_50V_J_X
LABC7, LABC23, LABC24: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
LABC20, LABC27: 4.7u/6/X5R/6.3V/K; 4.7u_6_X5R_6.3V_K
LABC22: 0.01u/4/X7R/25V/K/X; 0.01u_4_X7R_25V_K_X
LABC25: 0/4/SHT/M/X; 0_4_SHT_M_X
LAC1, LAC2, LAC3, LAC4: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
LAC5, LAC6: 27p/4/NPO/50V/J; 27p_4_NPO_50V_J
LAESD2, LAESD3: AZC099-04S.R7G/SOT23-6L/X; AZC099-04S.R7G_SOT23-6L_X
LAFB2: 0/6/SHT/M/X; 0_6_SHT_M_X
LAR1: 8.2K/4/X; 8.2K_4_X
LAR4: 1K/4/1; 1K_4_1
LAR5: 15K/4/1/X; 15K_4_1_X
LAR8, LAR9, LAR24: 0/6/SHT/M/X; 0_6_SHT_M_X
LAR12: 2.49K/4/1; 2.49K_4_1
LAR13: 150/4/1; 150_4_1
LAU1: RTL8111G-CG/QFN32; RTL8111G-CG_QFN32
LGA1150: HASWELL
MAF1: SPR-P200T/6V/8/S; SPR-P200T_6V_8_S
MBC1, MBC2, MBC3, MBC10, MBC12, MBC14: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
MBC9, MBC27, MBC29, MBC35, MBC37, MBC47: 1u/4/X5R/6.3V/K/X; 1u_4_X5R_6.3V_K_X
MBC15, MBC17, MBC18, MBC36: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
MBC24: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
MBC40: 10u/6/X5R/6.3V/M; 10u_6_X5R_6.3V_M
MC1, MC2, MC4, MC5, MC9, MC14: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
MC6, MC10, MC11: 100p/4/NPO/50V/J/X; 100p_4_NPO_50V_J_X
MEC1, MEC2: 560u/FP/D/6.3V/69/A/11m; 560u_FP_D_6.3V_69_A_11m
MH1, MH2, MH3, MH5, MH6: HOLE_3/X; HOLE_3_X
MH4: 180p/8P4C/6/NPO/50V/K; 180p_8P4C_6_NPO_50V_K
MR4, MR5, MR8, MR9, MR10, MR11, MR14, MR15: 1K/4/1; 1K_4_1
NBC2, NBC19, NBC20, NBC22, NBC26, NBC27, NBC28, NBC30, NBC44, NBC52, NBC54, NBC55, NBC56, NBC58, NBC64, NBC65, NBC68: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
NBC3, NBC60: 1u/4/X5R/6.3V/K/X; 1u_4_X5R_6.3V_K_X
NBC7: 10u/6/X5R/6.3V/M; 10u_6_X5R_6.3V_M
NBC21, NBC23, NBC46, NBC49, NBC51, NBC57, NBC67, NBC82, NBC83: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
NBC47, NBC62, NBC63: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
NBC66: 22u/8/X5R/6.3V/M; 22u_8_X5R_6.3V_M
NC1, NC2: 10p/4/NPO/50V/J/X; 10p_4_NPO_50V_J_X
NC7, NC8: 15p/4/NPO/50V/J; 15p_4_NPO_50V_J
NC15, NC19, NC20, NC23: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
NC16, NC18: 18P/4/NPO/50V/J; 18P_4_NPO_50V_J
NC17, NC58, NC59: 1n/4/X7R/50V/K; 1n_4_X7R_50V_K
NC26: 100p/4/NPO/50V/J/X; 100p_4_NPO_50V_J_X
NC37, NC38, NC39, NC40, NC41, NC42, NC43, NC44, NC45, NC46, NC47, NC48, NC54, NC55, NC56, NC57: 0/4/SHT/M/X; 0_4_SHT_M_X
NC51: 0.01u/4/X7R/25V/K/X; 0.01u_4_X7R_25V_K_X
NC60, NC61: 22p/4/NPO/50V/J; 22p_4_NPO_50V_J
ND1: BAS40-05/0.2A/SOT23; BAS40-05_0.2A_SOT23
NQ9: L1117LG/N/SOT223/1A; L1117LG_N_SOT223_1A
NQ13: MASK/MMBT2222A/SOT23/600mA/40/X; MASK_MMBT2222A_SOT23_600mA_40_X
NQ17, NQ19: 2N7002/SOT23/25pF/5; 2N7002_SOT23_25pF_5
NQ18: MMBT2222A/SOT23/600mA/40; MMBT2222A_SOT23_600mA_40
NR1, NR2, NR10, NR54, NR62, NR63: 8.2K/4/X; 8.2K_4_X
NR3, NR11, NR20, NR21: 1K/4/1/X; 1K_4_1_X
NR4, NR6, NR7, NR8, NR12, NR341, NR342, NR343, NR344: 0/4/SHT/M/X; 0_4_SHT_M_X
NR5, NR9, NR30, NR49, NR69, NR130, NR173, NR174, NR185: 8.2K/4; 8.2K_4
NR15, NR74: 1M/4; 1M_4
NR18, NR29, NR40, NR50, NR68: 7.5K/4/1; 7.5K_4_1
NR26, NR33, NR37, NR38, NR39: 33/4; 33_4
NR34: 649/4/1; 649_4_1
NR35, NR36, NR51, NR76, NR96, NR106, NR144, NR345: 1K/4/1; 1K_4_1
NR47: 22.6/4/1; 22.6_4_1
NR67, NR90: 390K/4; 390K_4
NR71: 5.1/4/1; 5.1_4_1
NR75: 10M/4; 10M_4
NR77, NR78, NR172: 20K/4/1; 20K_4_1
NR85: 0/4/X; 0_4_X
NR108: 51/4/1; 51_4_1
NR114, NR184: MASK/8.2K/4/X; MASK_8.2K_4_X
NR122, NR123: 499/4/1; 499_4_1
NR131: 680/4/1; 680_4_1
NR132: 1.47K/4/1; 1.47K_4_1
NR176: 301/4/1; 301_4_1
NR180: 510/4/1; 510_4_1
NR202: 22K/4; 22K_4
NR203: 75K/4/1; 75K_4_1
NR204: 27K/4/1; 27K_4_1
NR340: 0/6/SHT/M/X; 0_6_SHT_M_X
NR346: 100K/4/1; 100K_4_1
NRB1: 1K/4/1; 1K_4_1
NRN2, NRN3, NRN4, NRN6, NRN7, NRN9, NRN10, NRN11, NRN12, NRN13, NRN16, NRN17, NRN20, NRN21, NRN24: 8.2K/8P4R/4; 8.2K_8P4R_4
NRN18, NRN25: 1K/8P4R/4; 1K_8P4R_4
NRN22: 200/8P4R/4; 200_8P4R_4
NRN23: 100/8P4R/4; 100_8P4R_4
NTP1, NTP2, NTP3: TP/X; TP_X
NX1: 25M/12p/30ppm/49US/20/D; 25M_12p_30ppm_49US_20_D
NX2: 32.768K/12.5p/20ppm/TF38/35K/D; 32.768K_12.5p_20ppm_TF38_35K_D
OC1: 1n/4/X7R/50V/K; 1n_4_X7R_50V_K
OC2: 22p/4/NPO/50V/J/X; 22p_4_NPO_50V_J_X
OC3, OC7, OC15: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
OC4, OC6, OC16, OC17, OC22, OC24, OC27: 1u/4/X5R/6.3V/K; 1u_4_X5R_6.3V_K
OC5: 0.01u/4/X7R/25V/K; 0.01u_4_X7R_25V_K
OC8, OC10, OC14: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
OC9, OC12, OC18, OC19, OC20, OC21, OC23, OC25, OC26, OC28: 1u/4/X5R/6.3V/K/X; 1u_4_X5R_6.3V_K_X
OC11, OC13: 10u/6/X5R/6.3V/M; 10u_6_X5R_6.3V_M
OQ1: 2N7002/SOT23/25pF/5; 2N7002_SOT23_25pF_5
OR1, OR14, OR16, OR17, OR18: 1K/4/1; 1K_4_1
OR3, OR5, OR13, OR19, OR27, OR28, OR33, OR34, OR36, OR37, OR42, OR45, OR49: 8.2K/4; 8.2K_4
OR7: 22/4; 22_4
OR8: 0/4/SHT/M/X; 0_4_SHT_M_X
OR9: 0/4/X; 0_4_X
OR24, OR25, OR50: 8.2K/4/X; 8.2K_4_X
OR26: 100/4/1; 100_4_1
OR30: 680/4/1; 680_4_1
OR31: 1K/4/1/X; 1K_4_1_X
OR32, OR40, OR44, OR47: 10K/4/1; 10K_4_1
OR35: 1M/4; 1M_4
OR38: 6.49K/4/1; 6.49K_4_1
OR39: 75K/4/1; 75K_4_1
OR41, OR43: 15K/4/1; 15K_4_1
OR46, OR48: 10K/4/1/X; 10K_4_1_X
ORN1: 22/8P4R/4; 22_8P4R_4
ORN2: 1K/8P4R/4; 1K_8P4R_4
P2: FAN/1*4/WH/A3/PA66; FAN_1_4_WH_A3_PA66
PABC1, PABC2, PABC3: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
PAC1: 22p/4/NPO/50V/J/X; 22p_4_NPO_50V_J_X
PAC4, PAC5, PAC6, PAC7, PAC8, PAC9, PAC10, PAC11, PAC12, PAC13, PAC14, PAC15, PAC16, PAC17, PAC18, PAC19, PAC20, PAC21, PAC22, PAC23, PAC24, PAC25, PAC26, PAC27, PAC28, PAC29, PAC30, PAC31, PAC32, PAC33, PAC34, PAC35: 0.22u/4/X5R/6.3V/K; 0.22u_4_X5R_6.3V_K
PAR1, PAR2, PAR3: 0/4/SHT/M/X; 0_4_SHT_M_X
PARN1, PARN3, PARN5: 0/8P4R/0402/SHT/X; 0_8P4R_0402_SHT_X
PARN2, PARN4, PARN6: 0/8P4R/4/X; 0_8P4R_4_X
PCH1: BD82B81/S; BD82B81_S
PCH_HS1: PCH_HS
PCIEX1_2: PCI-E/1X-36P/BK/OL; PCI-E_1X-36P_BK_OL
PCIEX16: PCI-E/16X-164P/BK/LONG DOUBLE; PCI-E_16X-164P_BK_LONG_DOUBLE
PIC1, PIC2: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
PIR1, PIR2: 0/4/SHT/M/X; 0_4_SHT_M_X
PJC1, PJC2: 0.1u/4/X7R/16V/K; 0.1u_4_X7R_16V_K
PJR1, PJR2: 0/4/SHT/M/X; 0_4_SHT_M_X
PPC1, PPC12, PPC13: 0.1u/4/X7R/16V/K/X; 0.1u_4_X7R_16V_K_X
PPC2: 1u/4/X5R/6.3V/K/X; 1u_4_X5R_6.3V_K_X
PPC3: 22p/4/NPO/50V/J/X; 22p_4_NPO_50V_J_X
Q9, Q29, Q30, Q87: MMBT2222A/SOT23/600mA/40; MMBT2222A_SOT23_600mA_40
Q11, Q57, Q59, Q66, Q73, Q83, Q84: MASK/MMBT2222A/SOT23/600mA/40/X; MASK_MMBT2222A_SOT23_600mA_40_X
Q28, Q47, Q48, Q86: 2N7002/SOT23/25pF/5; 2N7002_SOT23_25pF_5
Q42: AP431N/SOT23/150mA/X; AP431N_SOT23_150mA_X
Q53: NTMFS4C10NT1G/PPAK/970pF/7.3m; NTMFS4C10NT1G_PPAK_970pF_7.3m
Q61: L1085DG/TO252/5A; L1085DG_TO252_5A
Q65: BAT54C/SOT23/200mA/X; BAT54C_SOT23_200mA_X
Q67: MASK/PMBT2907A/SOT23/-600mA/50/X; MASK_PMBT2907A_SOT23_-600mA_50_X
Q69: P2003ED/P/TO252/30m; P2003ED_P_TO252_30m
R3, R168, R703: 330/4/1; 330_4_1
R4, R659, R5009, R5018: 0/4/SHT/M/X; 0_4_SHT_M_X
R34, R62, R380: 3.3K/4/1; 3.3K_4_1
R37, R63: 15K/4/1; 15K_4_1
R38, R64: 6.2K/4/1; 6.2K_4_1
R56, R57, R58, R59: 82/6; 82_6
R60, R374: 0/6/SHT/M/X; 0_6_SHT_M_X
R65, R169, R181, R223, R387: 100/4/1; 100_4_1
R76, R97, R170, R172, R178, R186, R188, R222, R340, R390, R5015: 8.2K/4; 8.2K_4
R144, R145, R146, R147: 2.2K/4/1; 2.2K_4_1
R150, R151, R152, R185, R187: 75/4/1; 75_4_1
R171: 470/4/1; 470_4_1
R175: 33/4; 33_4
R179, R182, R324, R341, R388, R389, R398: 1K/4/1; 1K_4_1
R183, R198: 499/4/1; 499_4_1
R184, R192, R199: 10K/4/1; 10K_4_1
R189: 5.23K/4/1; 5.23K_4_1
R191: 13.7K/4/1; 13.7K_4_1
R225, R228, R313, R314, R403, R404: 1K/4/1/X; 1K_4_1_X
R226, R229, R393, R424, R672, R673, R704, R706: 8.2K/4/X; 8.2K_4_X
R227: 330/4/1/X; 330_4_1_X
R300: 220/6/X; 220_6_X
R326, R360: 22K/4; 22K_4
R357, R373, R381: 2.2/6; 2.2_6
R371: 3K/4/1; 3K_4_1
R372: 32.4K/4/1; 32.4K_4_1
R383: 150K/4/X; 150K_4_X
R384: 1M/4/1/X; 1M_4_1_X
R394: 330K/4/1; 330K_4_1
R395: 169/4/1; 169_4_1
R396: 20K/4/1; 20K_4_1
R399: 100K/4/1/X; 100K_4_1_X
R657: 680/4/1; 680_4_1
R658: 0/4/X; 0_4_X
R705: 825/4/1/X; 825_4_1_X
R707: 0/6/X; 0_6_X
R5016: 17.4K/4/1; 17.4K_4_1
R5017: 13.3K/4/1; 13.3K_4_1
R5019: 16.9K/4/1; 16.9K_4_1
RB_TP1: TP/X; TP_X
RN1: 8.2K/8P4R/6; 8.2K_8P4R_6
RN2, RN3, RN4, RN5, RN6: 2.7K/8P4R/4; 2.7K_8P4R_4
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
Connections (part):
0_8LEVEL_DDR: C193.2, R371.2, R380.1, R658.2, U8#2.6
1_5LG: G1.1, R372.1
2_5LEVEL: BC179.2, R189.1, R191.1, R300.1, R300.2
3VDUAL: BC161.1, G2#2.B10, LABC6.2, LAFB2.1, LAU1.23, NBC60.2, NBC63.2, NQ17.3, NR51.2, NR96.2, NR122.2, NR123.2, NR130.2, NR144.2, NR172.2, NR203.2, NRN6.3, NRN6.5, NRN6.7, NRN9.2, NRN9.4, NRN9.6, NRN9.8, NRN10.2, NRN10.4, NRN10.6, NRN10.8, NRN22.2, NRN22.4, NRN22.6, NRN25.1, NRN25.3, NRN25.5, NRN25.7, OC12.1, OR26.1, PCH1.AH18, PCH1.AH20, PCH1.AH22, PCH1.AJ20, PCH1.AK20, PCH1.AM33, PCH1.AN33, PCH1.AP35, PCH1.AW26, PCH1.P20, PCIEX1_2.B10, PCIEX16.B10, PPC2.1, Q61.2, R326.1, R387.1
3VDUAL_PCH: FPESD1.5, NBC65.2, NBC66.1, ND1.2, NQ9.2, NQ9.4, NR69.1, NR76.2, NR176.1, NRN20.2, NRN20.4, NRN20.6, NRN20.8, OC14.1, OR3.1, OR5.2, PCH1.AV39, PCH1.AW38, PCH1.AW39, R172.2, RB_TP1.1
5VAUX_SW: R389.2, R398.2, R424.1, R5015.2, SIO1.46
5VDUAL: BC164.1, C121.1, CD1.1, CR51.1, D5.1, EC14.2, F11.1, FF1.1, G#2.D1, G#2.D2, G#2.D3, G#2.D4, G#2.D5, L4.1, LAESD2.4, LAESD2.5, LAESD2.6, LAESD3.4, LAESD3.5, LAESD3.6, NR20.2, NR21.2, Q61.3, Q69.2, R706.1, UBEC2.2, UEC4.2, UEC6.2, UR3.1
5VSB: ATX1.9, BC151.1, EOS1.1, NBC68.1, NQ9.3, NR202.1, Q69.3, R97.1, R360.2, R383.1, R393.1, R394.1, R398.1, R704.1, RN23.2, RN23.4, RN23.6
15G: R357.2, U8#2.1
15HG: R340.2, R357.1
28_3VSB: OR26.2, SIO1.95
6609_VCC: DCC5.2, DCR14.1, DCU1.6
95812_FB: DR52.1, DR53.1, DR54.1, DR57.2
95812_FB_R: DBC17.1, DBC18.2, DBC19.1, DR54.2, DR55.2
95812_VDD: DBC10.2, DR41.2
95812_VDDP: DBC12.2, DR43.2
95812_VIN: DBC11.2, DR42.2
+12V: ATX1.10, ATX1.11, BC152.1, C322.2, D5.2, EC16.3, FC1.2, G#2.1, NR185.2, OR28.2, OR39.1, PARN1.1, PARN1.3, PARN1.5, PARN1.7, PARN2.1, PARN2.3, PARN2.5, PARN2.7, PARN3.1, PARN3.3, PARN3.5, PARN3.7, PARN4.1, PARN4.3, PARN4.5, PARN4.7, PARN5.1, PARN5.3, PARN5.5, PARN5.7, PARN6.1, PARN6.3, PARN6.5, PARN6.7, PPC1.1, R34.1, R60.2, R62.1, R390.1, RN2.1, RN2.3, RN2.5, RN2.7, RN3.1, RN3.3, RN3.5, RN3.7, RN4.1, RN4.3, RN4.5, RN4.7, RN5.1, RN5.3, RN5.5, RN5.7, RN6.1, RN6.3, RN6.5, RN6.7
+12V_LOAD: Q9.3, RN2.2, RN2.4, RN2.6, RN2.8, RN3.2, RN3.4, RN3.6, RN3.8, RN4.2, RN4.4, RN4.6, RN4.8, RN5.2, RN5.4, RN5.6, RN5.8, RN6.2, RN6.4, RN6.6, RN6.8
-12V: ATX1.14, BC146.1
-CASEOPEN: F_PANEL1.11, OC6.1, OC18.2, OR35.2, SIO1.97
-CSA0: DDR3_1.193, LGA1150.AU14
-CSA1: DDR3_1.76, LGA1150.AV9
-CSB0: DDR3_2.193, LGA1150.AP17
-CSB1: DDR3_2.76, LGA1150.AN15
-DCLKA0: DDR3_1.185, LGA1150.AY16
-DCLKA1: DDR3_1.64, LGA1150.AV15
-DCLKB0: DDR3_2.185, LGA1150.AM21
-DCLKB1: DDR3_2.64, LGA1150.AP21
-DDR3_RST: DDR3_1.168, DDR3_2.168, MC6.2, WC4.2, WR61.1
-DQSA0: DDR3_1.6, LGA1150.AE38
-DQSA1: DDR3_1.15, LGA1150.AJ38
-DQSA2: DDR3_1.24, LGA1150.AN38
-DQSA3: DDR3_1.33, LGA1150.AU36
-DQSA4: DDR3_1.84, LGA1150.AW5
-DQSA5: DDR3_1.93, LGA1150.AP2
-DQSA6: DDR3_1.102, LGA1150.AK2
-DQSA7: DDR3_1.111, LGA1150.AF2
-DQSB0: DDR3_2.6, LGA1150.AF34
-DQSB1: DDR3_2.15, LGA1150.AK33
-DQSB2: DDR3_2.24, LGA1150.AN33
-DQSB3: DDR3_2.33, LGA1150.AN29
-DQSB4: DDR3_2.84, LGA1150.AN13
-DQSB5: DDR3_2.93, LGA1150.AR8
-DQSB6: DDR3_2.102, LGA1150.AM8
-DQSB7: DDR3_2.111, LGA1150.AG6
-D_GPIO_HRST: NR51.1, PCH1.AN22
-HOLD0: NR341.1, R313.1, R672.1
-HOLD1: B_BIOS1.6, B_BIOS1.7, NR343.1, R314.1, R673.1
-PCIE_RST: G2#2.A11, OR17.2, ORN1.7, PAC1.2, PCIEX1_2.A11, PCIEX16.A11, PPC3.2
-PCIRSTIN: OR27.2, SIO1.32
-PFMRST2: LABC4.2, LAU1.19, OR18.2, ORN1.5
-PROCHOT_CON: OR13.2, SIO1.31, SIO1.89
-PSON: ATX1.16, BC147.1, R360.1, SIO1.105
-PVIDALRT: DR44.2, WR2.2, WR4.2, WR5.1
-PWRBTSW: BC67.1, R175.2, SIO1.104
-PWRBT_1: FPESD1.4, F_PANEL1.6, R172.1, R175.1
-RST: BC75.1, FPESD1.6, F_PANEL1.7, R181.1
-RST_BTN: OR1.2, SIO1.59
-SCASA: DDR3_1.74, LGA1150.AU9
-SCASB: DDR3_2.74, LGA1150.AP16
-SPI_CS_1: NC1.2, NR7.1, R3.2, R4.1
-SPI_CS_2: NR8.1, Q84.3, R227.2
-SPI_HOLD_B: B_BIOS1.5, NR11.1, NR21.1, R226.1, R404.2, R673.2, SIO1.35
-SPI_HOLD_M: NR3.1, NR20.1, R229.1, R403.2, R672.2, SIO1.34
-SRASA: DDR3_1.192, LGA1150.AU12
-SRASB: DDR3_2.192, LGA1150.AM18
-SWEA: DDR3_1.73, LGA1150.AU11
-SWEB: DDR3_2.73, LGA1150.AK16
AGND: AUDIO1.1, AUDIO1.A1, AUDIO1.C4, BC8.2, CBC4.1, CBC4.2, CBC7.1, CBC8.1, CBC10.1, CBC12.1, CBC19.2, CBC23.2, CBC24.2, CBC26.2, CBC29.2, CBC30.2, CBC36.2, CBC37.2, CBC42.1, CBC43.1, CR6.1, CR7.1, CR21.1, CR21.2, CR24.1, CR34.2, CR49.1, CR50.1, CR54.2, CR55.2, CR58.2, CR59.2, CR79.1, CR80.1, CU1.26, CU1.42, ESD18.2, G2#3.2, KB_MS1.14, KB_MS1.16, LAR24.1, MH2.1, MH2.2, MH2.3, MH2.4, MH2.5, MH2.6, MH2.7, MH2.8, MH2.9, MH2.10, MH2.11, MH2.12, MH2.13, MH3.2, MH3.4, MH3.6, MH4.2, MH4.4, MH4.6, MH4.8, R707.2, R_USB30.G2, R_USB30.G4, USB_LAN1.G2, USB_LAN1.G4, USB_LAN1.G6, USB_LAN1.G8
AJ_A2: AUDIO1.C2, CBC20.1, CR14.1
AJ_A5: CBC23.1, CR1.1
AJ_B2: CBC19.1, CR7.2, CR8.1
AJ_B5: AUDIO1.B5, CR5.1, CR6.2
AVDD: CBC10.2, CBC12.2, CU1.25, CU1.38
A_-CPURST: LGA1150.M39, PCH1.F41, WBC102.1
A_-HPRDY: LGA1150.L39, WRN14.8
A_-PROCHOT: LGA1150.K38, SIO1.56, WR25.2
A_-SKTOCC: LGA1150.D38, NRN10.1, PCH1.AE34
A_-THRMTRIP: LGA1150.F37, WR8.1, WR34.1, WR68.1
A_-TRST: LGA1150.E37, WRN14.4
A_DDR_COMP0: LGA1150.R1, WR28.1
A_DDR_COMP1: LGA1150.P1, WR19.1
A_DDR_COMP2: LGA1150.R2, WR22.1
A_DMI_0RXN: LGA1150.T3, PCH1.C20
A_DMI_0RXP: LGA1150.U3, PCH1.B20
A_DMI_0TXN: LGA1150.AA5, PCH1.L24
A_DMI_0TXP: LGA1150.AA4, PCH1.K24
A_DMI_1RXN: LGA1150.V1, PCH1.D21
A_DMI_1RXP: LGA1150.U1, PCH1.B21
A_DMI_1TXN: LGA1150.AB4, PCH1.G24
A_DMI_1TXP: LGA1150.AB3, PCH1.H24
A_DMI_2RXN: LGA1150.V2, PCH1.B22
A_DMI_2RXP: LGA1150.W2, PCH1.C22
A_DMI_2TXN: LGA1150.AC4, PCH1.F26
A_DMI_2TXP: LGA1150.AC5, PCH1.G26
A_DMI_3RXN: LGA1150.W3, PCH1.A24
A_DMI_3RXP: LGA1150.Y3, PCH1.B24, WR66.2, WR67.1
A_DMI_3TXN: LGA1150.AC2, PCH1.K26
A_DMI_3TXP: LGA1150.AC1, PCH1.L26
A_HSW_CFG_RCOMP: LGA1150.H40, WR24.1
A_PECI: LGA1150.N37, NR85.1, SIO1.88
A_PMSYNC: LGA1150.P36, PCH1.F40
A_PWR_DEBUG: LGA1150.N40
A_SM_VREF: LGA1150.AB38, WC3.2, WR60.2, WR62.1
A_SO: PCH1.AU22
A_SYC: PCH1.AV24
A_TCK: LGA1150.D39, WRN14.2
A_TESTLOW_1: LGA1150.P6, WR18.1
A_TESTLOW_2: LGA1150.N5, WR12.1
BEEP-: Q28.2, R178.1, SIO1.54
BOOT: DCU1.2
CEB_N: OR30.2, OR31.2, SIO1.99
CKEA0: DDR3_1.50, LGA1150.AV22
CKEA1: DDR3_1.169, LGA1150.AT23
CKEB0: DDR3_2.50, LGA1150.AW29
CKEB1: DDR3_2.169, LGA1150.AY29
CK_-DOTCLK: NRN16.7, PCH1.AP11
CK_-SRCCLK_PCH: NRN17.7, PCH1.G22
CK_-SRCCLK_SATA: NR173.1, PCH1.H35
CK_DOTCLK: NRN16.5, PCH1.AM11
CK_SRCCLK_PCH: NRN17.5, PCH1.F22
CK_SRCCLK_SATA: NR174.1, PCH1.H36
COUPON1: COUPON1.1
COUPON2: COUPON2.1
CPU_VAXG: LGA1150.R33, OR42.1
CPU_VTT_OR: DBC13.2, DR44.1, DR45.1, DR46.1, DR47.1, LGA1150.L40, WBC1.2, WR2.1, WR4.1, WR25.1, WRN14.7
C_-ACZ_RST: A1.7, CU1.11
C_ACZ_BITCLK: A1.1, A1.3, A1.5
C_ACZ_SDIN2: CR61.2, PCH1.AT22
C_ACZ_SDOUT: CU1.5
C_ACZ_SYNC: A1.2, A1.4, A1.6, A1.8, CU1.10
DCLKA0: DDR3_1.184, LGA1150.AY15
DCLKA1: DDR3_1.63, LGA1150.AW15
DCLKB0: DDR3_2.184, LGA1150.AM20
DCLKB1: DDR3_2.63, LGA1150.AP22
DDRVTT: DDR3_1.120, DDR3_1.240, DDR3_2.120, DDR3_2.240, MBC10.2, MBC18.2, MBC40.2
DDR_15V: BC140.1, DDR3_1.51, DDR3_1.54, DDR3_1.57, DDR3_1.60, DDR3_1.62, DDR3_1.65, DDR3_1.66, DDR3_1.69, DDR3_1.72, DDR3_1.75, DDR3_1.78, DDR3_1.170, DDR3_1.173, DDR3_1.176, DDR3_1.179, DDR3_1.182, DDR3_1.183, DDR3_1.186, DDR3_1.189, DDR3_1.191, DDR3_1.194, DDR3_1.197, DDR3_2.51, DDR3_2.54, DDR3_2.57, DDR3_2.60, DDR3_2.62, DDR3_2.65, DDR3_2.66, DDR3_2.69, DDR3_2.72, DDR3_2.75, DDR3_2.78, DDR3_2.170, DDR3_2.173, DDR3_2.176, DDR3_2.179, DDR3_2.182, DDR3_2.183, DDR3_2.186, DDR3_2.189, DDR3_2.191, DDR3_2.194, DDR3_2.197, G#3.D1, G#3.D2, G#3.D3, G#3.D4, L3.2, LGA1150.AJ9, LGA1150.AJ12, LGA1150.AJ13, LGA1150.AJ15, LGA1150.AJ17, LGA1150.AJ20, LGA1150.AJ21, LGA1150.AJ24, LGA1150.AJ25, LGA1150.AJ28, LGA1150.AJ29, LGA1150.AT17, LGA1150.AT22, LGA1150.AU15, LGA1150.AU20, LGA1150.AU24, LGA1150.AV8, LGA1150.AV10, LGA1150.AV11, LGA1150.AV13, LGA1150.AV18, LGA1150.AV23, LGA1150.AW16, LGA1150.AY9, LGA1150.AY12, LGA1150.AY14, MBC1.2, MBC2.2, MBC3.2, MBC9.2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
DDR_15VIO: OR37.1, R5018.1
DDR_EN_CON: C134.2, R396.2, SIO1.93, U8#2.7, U8#2.8, U18.1
DDR_VTT_REF: C100.1, R324.1, R341.2, U6.3
DMI_COMP: NR50.2, PCH1.B19
DQSA0: DDR3_1.7, LGA1150.AE39
DQSA1: DDR3_1.16, LGA1150.AJ39
DQSA2: DDR3_1.25, LGA1150.AN39
DQSA3: DDR3_1.34, LGA1150.AV36
DQSA4: DDR3_1.85, LGA1150.AV5
DQSA5: DDR3_1.94, LGA1150.AP3
DQSA6: DDR3_1.103, LGA1150.AK3
DQSA7: DDR3_1.112, LGA1150.AF3
DQSB0: DDR3_2.7, LGA1150.AF35
DQSB1: DDR3_2.16, LGA1150.AL33
DQSB2: DDR3_2.25, LGA1150.AP33
DQSB3: DDR3_2.34, LGA1150.AN28
DQSB4: DDR3_2.85, LGA1150.AN12
DQSB5: DDR3_2.94, LGA1150.AP8
DQSB6: DDR3_2.103, LGA1150.AL8
DQSB7: DDR3_2.112, LGA1150.AG7
FAN1_SET: FC3.2, FR3.2, FU14.4
FAN1_VOUT: SYS_FAN1.2
FANIO1: C16.1, R63.2, R64.1, SIO1.36
FANIO2: C9.1, R37.2, R38.1, SIO1.38
FANPWM1: OR19.1, R65.1, SIO1.37
FANPWM2: FR2.2, FR3.1, FU14.5, SIO1.39
FAUDIO_JD: CBC26.1, CR44.1, G2#3.7
FDI_CSYNC: LGA1150.D16, PCH1.L2
FDI_INT: LGA1150.D18, PCH1.L3
FDI_RCOMP: LGA1150.R4, WR23.2
FDI_TXN0: LGA1150.B14, PCH1.N1
FDI_TXN1: LGA1150.C13, PCH1.P2
FDI_TXP0: LGA1150.A14, PCH1.N2
FDI_TXP1: LGA1150.B13, PCH1.P3
FRONT_JD: AUDIO1.B3, CBC24.1, CR20.1
FUSEVCC_F: ESD5.5, ESD6.5, F_USB1.1, F_USB1.2, F_USB2.1, F_USB2.2, UBC1.1, UBC2.1, UBC3.1, UBC4.1, UR1.1
FUSEVCC_R: BC8.1, BC63.1, ESD18.5, FR1.1, FR1.2, KB_MS1.4, KB_MS1.10, LABC7.2, LABC23.2, RN1.5, RN1.6, RN1.7, RN1.8, UBESD3.5, UD5.1, VGA1.9
FUSEVCC_USB3_R3: BC5.1, BC6.1, ESD1.5, R_USB30.U10, UD5.2
GND: ATX1.3, ATX1.5, ATX1.7, ATX1.15, ATX1.17, ATX1.18, ATX1.19, ATX1.24, ATX_12V1.2, BC5.2, BC6.2, BC20.1, BC21.1, BC63.2, BC67.2, BC75.2, BC78.2, BC79.2, BC84.2, BC140.2, BC146.2, BC147.2, BC148.2, BC149.2, BC150.2, BC151.2, BC152.2, BC153.2, BC154.2, BC158.2, BC161.2, BC162.2, BC164.2, BC179.1, B_BIOS1.2, B_BIOS1.3, B_BIOS1.4, C9.2, C12.2, C16.2, C31.2, C32.1, C33.2, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.2, C100.2, C104.2, C119.2, C120.2, C121.2, C131.2, C132.2, C143.2, C144.2, C318.2, C322.1, C323.2, CBC32.2, CBC34.1, CBC35.1, CBC38.2, CD1.2, CR50.2, CR65.1, CU1.7, DAC1.1, DAC3.2, DBC1.1, DBC3.2, DBC10.1, DBC11.1, DBC12.1, DBC13.1, DBC15.1, DBC16.1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
GP24: SIO1.52, U8#2.5
GP25: R5016.1, R5017.2, SIO1.51
GP26: R5016.2, SIO1.50
GRCOMP: LGA1150.P3, WR15.2
HD+: F_PANEL1.1, R168.2
H_SYNC: NR26.1, PCH1.AH3
IO_EN1: C132.1, Q66.2, Q73.3, R383.2, R384.1, R394.2
ISEN1: DAR9.1, DBR11.1, DCR11.1
ISEN2: DAR11.1, DBR9.1, DCR12.1
ISEN3: DAR12.1, DBR12.1, DCR9.1
ITE_PWROK1: OR16.2, ORN1.2, SIO1.61
IT_AVCC: OC13.1, OQ1.3, OR9.2, SIO1.128
IT_VCCH: OC3.1, OC9.1, OC10.1, OC11.1, OR8.1, SIO1.33, SIO1.64, SIO1.96
JP2: ORN2.7, SIO1.23
JP3: ORN2.5, SIO1.25
JP4: ORN2.1, SIO1.27
JP5: OR24.2, OR25.2, SIO1.58
KBCLK: ESD18.1, MH4.1
KBDATA: ESD18.3, MH4.3
KCLK: RN1.1, RN1.3, SIO1.110
KDAT: SIO1.109
L2-L: CBC36.1, CR53.2, CR54.1, CRN1.8, G2#3.9
L2-R: CR57.2, CR58.1, CRN1.6, G2#3.5
L2_L: CEC6.1, CR53.1
L2_R: CR57.1, G#14.1
LAN_3VDUAL_LED: LABC24.1, LAR13.2
LA_-SRCCLK_LAN: LAU1.16, PCH1.AC11
LA_CLKREQB: LAR1.1, LAU1.12
LA_DVDD10: LABC2.2, LABC3.2, LABC8.2, LABC9.2, LAR8.1, LAU1.3, LAU1.8, LAU1.22, LAU1.30
LA_LED_ACT_TXRX: LAU1.27
LA_LED_D2: USB_LAN1.D2
LA_LED_LINK100: LAU1.26
LA_LED_LINK1000: LAU1.25, USB_LAN1.D4
LA_MDI0+: LAU1.1, USB_LAN1.L2
LA_MDI0-: LAU1.2
LA_MDI1+: LAU1.4, USB_LAN1.L4
LA_MDI1-: LAU1.5
LA_MDI2+: LAU1.6, USB_LAN1.L6
LA_MDI2-: LAU1.7
LA_MDI3+: LAU1.9, USB_LAN1.L8
LA_MDI3-: LAU1.10
LA_ML_IN: LAC4.1, PCH1.F11
LA_ML_IN_C: LAC4.2, LAU1.18
LA_ML_IP: LAC1.1, PCH1.H11
LA_ML_IP_C: LAC1.2, LAU1.17
LA_ML_ON: LAC2.1, PCH1.B9
LA_ML_ON_C: LAC2.2, LAU1.14
LA_ML_OP: LAC3.1, PCH1.A9
LA_ML_OP_C: LAC3.2, LAU1.13
LA_REGOUT: LABC5.2, LAU1.24
LA_RSET: LAR12.2, LAU1.31
LA_SRCCLK_LAN: LAU1.15, PCH1.AC10
LA_VDD33: LABC14.1, LABC18.2, LABC20.1, LABC27.1, LAR9.1, LAU1.11, LAU1.32
LA_XTALI: G#5.1, LAU1.28
LA_XTALO: LAU1.29
LG1_1: DAR3.1, G#7.D2, G#7.D3, G#7.D4, G#7.D5, G#12.1
LG2_1: DBR3.1, G#10.1
LG3: DCU1.5
LG3_1: DCQ2.1, DCR3.1, G#8.1
LINE1_JD: CR23.1
LINE2_L: CU1.14
LINE2_R: CU1.15
LINE2_VREFO: CQ4.3, CU1.31
LINE_IN_L: CBC2.1, CR14.2
LINE_IN_R: CBC1.1, CR1.2
LINE_O_L: CU1.35
LINE_O_R: CU1.36
M2_L: CR12.1, CR13.2, CRN1.4, G2#3.1
M2_R: CBC29.1, CBC30.1, CR11.2, CR12.2, CRN1.2, G2#3.3
MAAA0: DDR3_1.188, LGA1150.AU13
MAAA1: DDR3_1.181, LGA1150.AV16
MAAA2: DDR3_1.61, LGA1150.AU16
MAAA3: DDR3_1.180, LGA1150.AW17
MAAA4: DDR3_1.59, LGA1150.AU17
MAAA5: DDR3_1.58, LGA1150.AW18
MAAA6: DDR3_1.178, LGA1150.AV17
MAAA7: DDR3_1.56, LGA1150.AT18
MAAA8: DDR3_1.177, LGA1150.AU18
MAAA9: DDR3_1.175, LGA1150.AT19
MAAA10: DDR3_1.70, LGA1150.AW11
MAAA11: DDR3_1.55, LGA1150.AV19
MAAA12: DDR3_1.174, LGA1150.AU19
MAAA13: DDR3_1.196, LGA1150.AY10
MAAA14: DDR3_1.172, LGA1150.AT20
MAAA15: DDR3_1.171, LGA1150.AU21
MAAB0: DDR3_2.188, LGA1150.AL19
MAAB1: DDR3_2.181, LGA1150.AK23
MAAB2: DDR3_2.61, LGA1150.AM22
MAAB3: DDR3_2.180, LGA1150.AM23
MAAB4: DDR3_2.59, LGA1150.AP23
MAAB5: DDR3_2.58, LGA1150.AL23
MAAB6: DDR3_2.178, LGA1150.AY24
MAAB7: DDR3_2.56, LGA1150.AV25
MAAB8: DDR3_2.177, LGA1150.AU26
MAAB9: DDR3_2.175, LGA1150.AW25
MAAB10: DDR3_2.70, LGA1150.AP18
MAAB11: DDR3_2.55, LGA1150.AY25
MAAB12: DDR3_2.174, LGA1150.AV26
MAAB13: DDR3_2.196, LGA1150.AR15
MAAB14: DDR3_2.172, LGA1150.AV27
MAAB15: DDR3_2.171, LGA1150.AY28
MB_ID2: OR49.1, OR50.1, SIO1.90
MCLK: SIO1.112
MDA0: DDR3_1.3, LGA1150.AD38
MDA1: DDR3_1.4, LGA1150.AD39
MDA2: DDR3_1.9, LGA1150.AF38
MDA3: DDR3_1.10, LGA1150.AF39
MDA4: DDR3_1.122, LGA1150.AD37
MDA5: DDR3_1.123, LGA1150.AD40
MDA6: DDR3_1.128, LGA1150.AF37
MDA7: DDR3_1.129, LGA1150.AF40
MDA8: DDR3_1.12, LGA1150.AH38
MDA9: DDR3_1.13, LGA1150.AH40
MDA10: DDR3_1.18, LGA1150.AK38
MDA11: DDR3_1.19, LGA1150.AK39
MDA12: DDR3_1.131, LGA1150.AH37
MDA13: DDR3_1.132, LGA1150.AH39
MDA14: DDR3_1.137, LGA1150.AK37
MDA15: DDR3_1.138, LGA1150.AK40
MDA16: DDR3_1.21, LGA1150.AM38
MDA17: DDR3_1.22, LGA1150.AM40
MDA18: DDR3_1.27, LGA1150.AP38
MDA19: DDR3_1.28, LGA1150.AP39
MDA20: DDR3_1.140, LGA1150.AM37
MDA21: DDR3_1.141, LGA1150.AM39
MDA22: DDR3_1.146, LGA1150.AP37
MDA23: DDR3_1.147, LGA1150.AP40
MDA24: DDR3_1.30, LGA1150.AU37
MDA25: DDR3_1.31, LGA1150.AV37
MDA26: DDR3_1.36, LGA1150.AU35
MDA27: DDR3_1.37, LGA1150.AV35
MDA28: DDR3_1.149, LGA1150.AT37
MDA29: DDR3_1.150, LGA1150.AW37
MDA30: DDR3_1.155, LGA1150.AT35
MDA31: DDR3_1.156, LGA1150.AW35
MDA32: DDR3_1.81, LGA1150.AV6
MDA33: DDR3_1.82, LGA1150.AY6
MDA34: DDR3_1.87, LGA1150.AV4
MDA35: DDR3_1.88, LGA1150.AU4
MDA36: DDR3_1.200, LGA1150.AW6
MDA37: DDR3_1.201, LGA1150.AU6
MDA38: DDR3_1.206, LGA1150.AW4
MDA39: DDR3_1.207, LGA1150.AY4
MDA40: DDR3_1.90, LGA1150.AR3
MDA41: DDR3_1.91, LGA1150.AR1
MDA42: DDR3_1.96, LGA1150.AN3
MDA43: DDR3_1.97, LGA1150.AN4
MDA44: DDR3_1.209, LGA1150.AR2
MDA45: DDR3_1.210, LGA1150.AR4
MDA46: DDR3_1.215, LGA1150.AN2
MDA47: DDR3_1.216, LGA1150.AN1
MDA48: DDR3_1.99, LGA1150.AL3
MDA49: DDR3_1.100, LGA1150.AL1
MDA50: DDR3_1.105, LGA1150.AJ3
MDA51: DDR3_1.106, LGA1150.AJ4
MDA52: DDR3_1.218, LGA1150.AL2
MDA53: DDR3_1.219, LGA1150.AL4
MDA54: DDR3_1.224, LGA1150.AJ2
MDA55: DDR3_1.225, LGA1150.AJ1
MDA56: DDR3_1.108, LGA1150.AG3
MDA57: DDR3_1.109, LGA1150.AG1
MDA58: DDR3_1.114, LGA1150.AE3
MDA59: DDR3_1.115, LGA1150.AE4
MDA60: DDR3_1.227, LGA1150.AG2
MDA61: DDR3_1.228, LGA1150.AG4
MDA62: DDR3_1.233, LGA1150.AE2
MDA63: DDR3_1.234, LGA1150.AE1
MDAT: RN1.2, RN1.4, SIO1.111
MDB0: DDR3_2.3, LGA1150.AE34
MDB1: DDR3_2.4, LGA1150.AE35
MDB2: DDR3_2.9, LGA1150.AG35
MDB3: DDR3_2.10, LGA1150.AH35
MDB4: DDR3_2.122, LGA1150.AD34
MDB5: DDR3_2.123, LGA1150.AD35
MDB6: DDR3_2.128, LGA1150.AG34
MDB7: DDR3_2.129, LGA1150.AH34
MDB8: DDR3_2.12, LGA1150.AL34
MDB9: DDR3_2.13, LGA1150.AL35
MDB10: DDR3_2.18, LGA1150.AK31
MDB11: DDR3_2.19, LGA1150.AL31
MDB12: DDR3_2.131, LGA1150.AK34
MDB13: DDR3_2.132, LGA1150.AK35
MDB14: DDR3_2.137, LGA1150.AK32
MDB15: DDR3_2.138, LGA1150.AL32
MDB16: DDR3_2.21, LGA1150.AP35
MDB17: DDR3_2.22, LGA1150.AN34
MDB18: DDR3_2.27, LGA1150.AN32
MDB19: DDR3_2.28, LGA1150.AN31
MDB20: DDR3_2.140, LGA1150.AN35
MDB21: DDR3_2.141, LGA1150.AP34
MDB22: DDR3_2.146, LGA1150.AP32
MDB23: DDR3_2.147, LGA1150.AP31
MDB24: DDR3_2.30, LGA1150.AL29
MDB25: DDR3_2.31, LGA1150.AM29
MDB26: DDR3_2.36, LGA1150.AP29
MDB27: DDR3_2.37, LGA1150.AR29
MDB28: DDR3_2.149, LGA1150.AM28
MDB29: DDR3_2.150, LGA1150.AL28
MDB30: DDR3_2.155, LGA1150.AR28
MDB31: DDR3_2.156, LGA1150.AP28
MDB32: DDR3_2.81, LGA1150.AR12
MDB33: DDR3_2.82, LGA1150.AP12
MDB34: DDR3_2.87, LGA1150.AL13
MDB35: DDR3_2.88, LGA1150.AL12
MDB36: DDR3_2.200, LGA1150.AR13
MDB37: DDR3_2.201, LGA1150.AP13
MDB38: DDR3_2.206, LGA1150.AM13
MDB39: DDR3_2.207, LGA1150.AM12
MDB40: DDR3_2.90, LGA1150.AP10
MDB41: DDR3_2.91, LGA1150.AP9
MDB42: DDR3_2.96, LGA1150.AP7
MDB43: DDR3_2.97, LGA1150.AP6
MDB44: DDR3_2.209, LGA1150.AR10
MDB45: DDR3_2.210, LGA1150.AR9
MDB46: DDR3_2.215, LGA1150.AR7
MDB47: DDR3_2.216, LGA1150.AR6
MDB48: DDR3_2.99, LGA1150.AM10
MDB49: DDR3_2.100, LGA1150.AL10
MDB50: DDR3_2.105, LGA1150.AL6
MDB51: DDR3_2.106, LGA1150.AM7
MDB52: DDR3_2.218, LGA1150.AM9
MDB53: DDR3_2.219, LGA1150.AL9
MDB54: DDR3_2.224, LGA1150.AM6
MDB55: DDR3_2.225, LGA1150.AL7
MDB56: DDR3_2.108, LGA1150.AJ6
MDB57: DDR3_2.109, LGA1150.AJ7
MDB58: DDR3_2.114, LGA1150.AF6
MDB59: DDR3_2.115, LGA1150.AE6
MDB60: DDR3_2.227, LGA1150.AH7
MDB61: DDR3_2.228, LGA1150.AH6
MDB62: DDR3_2.233, LGA1150.AF7
MDB63: DDR3_2.234, LGA1150.AE7
MIC1_JD: CBC3.1, CR18.1
MIC1_L: CBC11.1, CR22.2
MIC1_R: CBC9.1, CR17.2
MIC1_VREFO_L: AUDIO1.A2, CBC3.2, CR19.1, CR22.1
MIC1_VREFO_R: AUDIO1.A5, CR16.1, CR17.1
MIC2_L: CBC6.1, CU1.16
MIC2_R: CBC5.1, CU1.17
MIC2_VREFO: CQ2.3, CU1.30
MODT_A0: DDR3_1.195, LGA1150.AW10
MODT_A1: DDR3_1.77, LGA1150.AY8
MODT_B0: DDR3_2.195, LGA1150.AM17
MODT_B1: DDR3_2.77, LGA1150.AL16
MPD+: F_PANEL1.2, F_PANEL1.15, SIO1.82
MPD-: F_PANEL1.4, R171.2, SIO1.92
MSCLK: ESD18.4, MH4.7
MSDATA: ESD18.6, MH4.5
N05264: OQ1.2, OR28.1
N5366609: CEC1.1, CR5.2
N5366636: CEC2.1, CR8.2
N5375288: CBC6.2, CR13.1
N5375315: CBC5.2, CR11.1
N13760503: Q30.2, R186.1
N16871456: CBC20.2, CBC43.2, CR18.2, CR20.2, CR23.2, CU1.13
N16871464: CR44.2, CU1.34
N16871482: CBC32.1, CR60.1, CU1.6
N16871486: CBC42.2, CR34.1, CU1.40
N16871955: CBC34.2, CR63.1, CU1.1
N16871974: CBC7.2, CU1.29
N16871979: CR65.2, CU1.4
N16871983: CR61.1, CU1.8
N16872002: CBC8.2, CU1.27
N16872076: CBC2.2, CU1.23
N16872082: CBC9.2, CU1.22
N16872084: CBC11.2, CU1.21
N16872096: CBC1.2, CU1.24
N16872296: CBC35.2, CU1.3
N16952299: CR78.1, G2#3.4
N17013037: DBC14.2, DBC15.2, DR50.1
N17076531: PCH1.AV23
N17076629: PCH1.AU24
N18609742: D4.3, NC23.2, NQ18.2, NR203.1, NR204.1
N19130720: D3.1, Q29.3, Q30.3, R185.1, R187.1
N21168700: DR60.2, DRT1.1
N21513130: DBC24.2, DR68.1
N21513143: DBC24.1, DR67.2
N22095557: NBC2.1
N23100246: NR29.1, PCH1.K2
N23891470: C131.1, Q65.1, Q65.2, R381.1, U8#2.4
N23891582: C136.1, Q65.3
N23891733: D5.3, R381.2
N23891784: BC162.1, C120.1, EC11.1, EC12.2, L4.2, Q53.D1, Q53.D2, Q53.D3, Q53.D4, Q53.D5
N23891833: C133.2, R396.1
N24888999: Q11.3, Q67.2, R384.2, R388.1, R393.2
N26626371: Q28.3, Q29.2, R179.1
N28032490: NBC67.2, NQ9.1, NR176.2, NR180.1
N29814820: BC154.1, U6.5
N29818181: R183.1, R184.1
N30641741: LGA1150.Y8
N30641932: LGA1150.C37, WR1.1, WR5.2
N30641991: LGA1150.T8
N30641996: LGA1150.C38, WR7.1
N30767566: LGA1150.AK22
N30880053: LGA1150.AC8
N31282471: PAR3.1, PCIEX16.B4
N32297624: NR62.2, PCH1.AK28
N32297700: NR63.2, PCH1.AT34
N32555455: PCIEX16.A1
N32624314: PCH1.AU40, PCH1.AU41
N36120215: C133.1, C134.1, R658.1, R659.1
N36283610: PCIEX1_2.B4, PJR1.1
N36283614: PCIEX1_2.A4
N36809121: DAR8.1
N36809135: DBR8.1
N37484841: DAR7.2, DAR9.2
N37485205: DBC22.2, DCR7.2, DCR9.2
N37485393: DBR7.2, DBR9.2
N38984599: DR64.2
N38984604: DR63.2
N38984609: DR62.2
N38984614: DR61.2
N38986900: DR69.2
N39004258: Q86.3, R390.2
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